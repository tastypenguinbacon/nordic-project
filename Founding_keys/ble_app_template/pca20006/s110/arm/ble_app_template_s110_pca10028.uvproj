# Keil uVision project ble_app_template_s110_pca10028.uvproj, settings and files
target nrf51422_xxac_s110 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA20006
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\bsp;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.0\CMSIS\Include;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\libraries\sensorsim
  asm define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10028
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE_Modules
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_ias/: ble_ias.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/sensorsim/: ble_sensorsim.c ble_sensorsim.h
  group nRF_SoftDevice_Internal
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
